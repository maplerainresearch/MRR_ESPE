# Repository maplerainresearch/MRR_ESPE (continued)

## KiCad design current/MRR_ESPE.kicad_pcb (continued)

Board: 2 copper layers, 102.0 x 102.0 mm, 168 parts (0 on the bottom side), 165 nets.

File current/MRR_ESPE_BOM.csv (part):

Reference, Value, Footprint, Datasheet, LCSC Part Number, Manufacturer, Mfg part no.
"U1","ESP32-WROOM-32D","RF_Module:ESP32-WROOM-32","https://www.espressif.com/sites/default/files/documentation/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","C95209","Espressif Systems","ESP32-WROOM-32"
"J9","PWR_IN","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-4-5.08_1x04_P5.08mm_Horizontal","~","C90087","Phoenix Contact","MKDS3/4-5.08"
"F1","15A 2410","projfp:Littelfuse_0451","Bel 0679H9150-01","C44480","Littelfuse","0451015.MRL"
"F2","30A 3912","projfp:Littelfuse_0456","Bel 0678H9300-02","C187558","Littelfuse","0456030.ER"
"D4","1N4007W","projfp:D_SOD-123F","http://www.vishay.com/docs/88503/1n4001.pdf","C108803","Shandong Jingdao Microelectronics","1N4007W"
"D5","1N4007W","projfp:D_SOD-123F","http://www.vishay.com/docs/88503/1n4001.pdf","C108803","Shandong Jingdao Microelectronics","1N4007W"
"U2","TPS54340DDA","Package_SO:TI_SO-PowerPAD-8_ThermalVias","http://www.ti.com/lit/ds/symlink/tps54340.pdf","C45886","Texas Instruments","TPS54340DDAR"
"C10","100nF50V","Capacitor_SMD:C_0805_2012Metric","~","C161260","Murata Electronics","GCM21BR71H104KA37L"
"C7","4.7uF50V","Capacitor_SMD:C_1206_3216Metric","~","C307575","Samsung Electro-Mechanics","CL31B475KBHNFNE"
"C4","100uF50V","Capacitor_SMD:CP_Elec_8x10","~","C176665","Lelon","VEJ101M1HTR-0810"
"L1","4.7uH4.5A","projfp:SMMS0530","~","C181722","Shun Xiang Nuo Elec","SMMS0530-4R7M"
"D9","B540C-13-F","projfp:D_SMC","~","C72264","Diodes Incorporated","B540C-13-F"
"R24","60.4K","Resistor_SMD:R_0805_2012Metric","~","C273994","YAGEO","RC0805FR-0760K4L"
"R25","11.5K","Resistor_SMD:R_0805_2012Metric","~","C17418","Uniroyal Elec","0805W8F1152T5E"
"C12","47uF10V","Capacitor_SMD:C_1206_3216Metric","~","C92821","Taiyo Yuden","LMK316BJ476ML-T"
"C8","820pF50V","Capacitor_SMD:C_0805_2012Metric","~","C152862","Walsin Tech Corp","0805B821K500CT"
"R21","23.7K","Resistor_SMD:R_0805_2012Metric","~","C170848","Walsin Tech Corp","WR08X2372FTL"
"C9","56pF50V","Capacitor_SMD:C_0805_2012Metric","~","C296102","Walsin Tech Corp","0805N560J500CT"
"R18","73.2K","Resistor_SMD:R_0805_2012Metric","~","C170958","Walsin Tech Corp","WR08X7322FTL"
"U4","AMS1117-3.3","Package_TO_SOT_SMD:SOT-223-3_TabPin2","http://www.advanced-monolithic.com/pdf/ds1117.pdf","C6186","Advanced Monolithic Systems","AMS1117-3.3"
"C14","47uF6.3V","Capacitor_SMD:C_0805_2012Metric","~","C87159","Taiyo Yuden","JMK212BJ476MG-T"
"C13","47uF6.3V","Capacitor_SMD:C_0805_2012Metric","~","C87159","Taiyo Yuden","JMK212BJ476MG-T"
"R28","220R","Resistor_SMD:R_0805_2012Metric","~","C17557","Uniroyal Elec","0805W8F2200T5E"
"D10","LED_3V","projfp:LED_0805","~","C73548","Everlight Elec","17-21SYGC/S530-E2/TR8"
"R29","330R","Resistor_SMD:R_0805_2012Metric","~","C17630","Uniroyal Elec","0805W8F3300T5E"
"R30","2.2K","Resistor_SMD:R_0805_2012Metric","~","C17520","Uniroyal Elec","0805W8F2201T5E"
"R31","2.2K","Resistor_SMD:R_0805_2012Metric","~","C17520","Uniroyal Elec","0805W8F2201T5E"
"D11","LED_5V","projfp:LED_0805","~","C73548","Everlight Elec","17-21SYGC/S530-E2/TR8"
"D12","LED_VIN","projfp:LED_0805","~","C72035","Everlight Elec","17-21/BHC-XL2M2TY/3T"
"D13","LED_VBED","projfp:LED_0805","~","C72035","Everlight Elec","17-21/BHC-XL2M2TY/3T"
"R26","0R","Resistor_SMD:R_0805_2012Metric","~","C17477","Uniroyal Elec","0805W8F0000T5E"
"R27","0R","Resistor_SMD:R_0805_2012Metric","~","C17477","Uniroyal Elec","0805W8F0000T5E"
"C11","1nF16V","Capacitor_SMD:C_0805_2012Metric","~","C52278","Guangdong Fenghua Advanced Tech","0805B103K500NT"
"J16","USB_B_Micro","Connector_USB:USB_Micro-B_Molex-105017-0001","~","C136000","MOLEX","105017-0001"
"D7","PESD5V0S1BA","projfp:D_SOD-323","~","C19224","Nexperia","PESD5V0S1BA,115"
"D8","PESD5V0S1BA","projfp:D_SOD-323","~","C19224","Nexperia","PESD5V0S1BA,115"
"Q4","S9014","Package_TO_SOT_SMD:SOT-23","http://www.onsemi.com/pub_link/Collateral/2N3055-D.PDF","C181164","Guangdong Hottech","S9014"
"Q5","S9014","Package_TO_SOT_SMD:SOT-23","http://www.onsemi.com/pub_link/Collateral/2N3055-D.PDF","C181164","Guangdong Hottech","S9014"
"R22","12K","Resistor_SMD:R_0805_2012Metric","~","C17444","Uniroyal Elec","0805W8F1202T5E"
"R23","12K","Resistor_SMD:R_0805_2012Metric","~","C17444","Uniroyal Elec","0805W8F1202T5E"
"Q1","IRLS3034PBF","Package_TO_SOT_SMD:TO-263-2","~"
"Q2","IRLR8743TRPBF","Package_TO_SOT_SMD:TO-252-2","~"
"R5","2.2K","Resistor_SMD:R_0805_2012Metric","~","C17520","Uniroyal Elec","0805W8F2201T5E"
"D1","LED_BED","projfp:LED_0805","~","C72037","Everlight Elec","17-21SURC/S530-A3/TR8"
"J3","BED","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal","~","C89120","Phoenix Contact","MKDS3/2-5.08"
"R9","2.2K","Resistor_SMD:R_0805_2012Metric","~","C17520","Uniroyal Elec","0805W8F2201T5E"
"J7","E0","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal","~","C91153","Phoenix Contact","MKDSN1.5/2-5.08"
"R10","10R","Resistor_SMD:R_0805_2012Metric","~","C17415","Uniroyal Elec","0805W8F100JT5E"
"R11","100K","Resistor_SMD:R_0805_2012Metric","~","C149504","Uniroyal Elec","0805W8F1003T5E"
"R13","10R","Resistor_SMD:R_0805_2012Metric","~","C17415","Uniroyal Elec","0805W8F100JT5E"
"R14","100K","Resistor_SMD:R_0805_2012Metric","~","C149504","Uniroyal Elec","0805W8F1003T5E"
"J10","PART_FAN","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","~","C124375","Shenzhen Cankemeng","C124375"
"U8","Pololu_board","Module:Pololu_Breakout-16_15.2x20.3mm","","C27438","Boom Precision Elec","x2"
"U5","Pololu_board","Module:Pololu_Breakout-16_15.2x20.3mm","","C27438","Boom Precision Elec","x2"
"J21","X_MOTOR","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","~","C124378","Shenzhen Cankemeng","C124378"
"C15","100uF35V","Capacitor_SMD:CP_Elec_6.3x7.7","~","C97811","Semtech","CS1V101M-CRE77"
"U6","Pololu_board","Module:Pololu_Breakout-16_15.2x20.3mm","","C27438","Boom Precision Elec","x2"
"U9","Pololu_board","Module:Pololu_Breakout-16_15.2x20.3mm","","C27438","Boom Precision Elec","x2"
"C16","100uF35V","Capacitor_SMD:CP_Elec_6.3x7.7","~","C97811","Semtech","CS1V101M-CRE77"
"C17","100uF35V","Capacitor_SMD:CP_Elec_6.3x7.7","~","C97811","Semtech","CS1V101M-CRE77"
"C18","100uF35V","Capacitor_SMD:CP_Elec_6.3x7.7","~","C97811","Semtech","CS1V101M-CRE77"
"J23","Y_MOTOR","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","~","C124378","Shenzhen Cankemeng","C124378"
"J24","E0_MOTOR","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","~","C124378","Shenzhen Cankemeng","C124378"
"J22","Z_MOTOR","Connector_PinHeader_2.54mm:PinHeader_2x04_P2.54mm_Vertical","~","C124386","Shenzhen Cankemeng","C124386"
"D3","LED_E0","projfp:LED_0805","~","C72037","Everlight Elec","17-21SURC/S530-A3/TR8"
"J12","T_BED","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","~","C124375","Shenzhen Cankemeng","C124375"
"R16","4.7K","Resistor_SMD:R_0805_2012Metric","~","C17673","Uniroyal Elec","0805W8F4701T5E"
"C5","22uF6.3V","Capacitor_SMD:C_0805_2012Metric","~","C5674","Samsung Electro-Mechanics","CL21A226MQQNNNE"
"J13","T_E0","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","~","C124375","Shenzhen Cankemeng","C124375"
"R17","4.7K","Resistor_SMD:R_0805_2012Metric","~","C17673","Uniroyal Elec","0805W8F4701T5E"
"C6","22uF6.3V","Capacitor_SMD:C_0805_2012Metric","~","C5674","Samsung Electro-Mechanics","CL21A226MQQNNNE"
"J1","X_MIN","Connector_JST:JST_XH_B03B-XH-A_1x03_P2.50mm_Vertical","~","C144394","JST Sales America","B3B-XH-A(LF)(SN)"
"R3","10K","Resistor_SMD:R_0805_2012Metric","~","C38522","Uniroyal Elec","0805W8F1002T5E"
"C1","100nF25V","Capacitor_SMD:C_0805_2012Metric","~","C128353","Walsin Tech Corp","0805B104K250"
"J5","Y_MIN","Connector_JST:JST_XH_B03B-XH-A_1x03_P2.50mm_Vertical","~","C144394","JST Sales America","B3B-XH-A(LF)(SN)"
"R8","10K","Resistor_SMD:R_0805_2012Metric","~","C38522","Uniroyal Elec","0805W8F1002T5E"
"C3","100nF25V","Capacitor_SMD:C_0805_2012Metric","~","C128353","Walsin Tech Corp","0805B104K250"
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
## Commit log

2019-05-30 Added v0.1
2019-06-19 Added v0.2
2019-10-10 Added v0.3 and v0.4
2019-10-10 Updated v0.4
2019-10-30 Added v0.5
2019-11-03 Minor change to v0.5 silkscreen
2019-11-12 Updated media
2019-11-12 Added cases
2019-11-12 Added case README
2019-11-12 Added PCB dimensions
2019-11-12 Added dimensions drawing
2019-11-25 Revised small case
2019-11-29 Updated BEEPER pin def
2019-12-08 Added v0.5rev1 to fix AUX1 issue
2019-12-13 Added adapter boards
2020-01-14 Updated manual
