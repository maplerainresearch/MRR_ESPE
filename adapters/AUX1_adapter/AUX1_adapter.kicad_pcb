# Repository maplerainresearch/MRR_ESPE

File README.md:

# MRR_ESPE
## A 3D printer control board based on ESP32

This is a 3D printer control board based on the ESP32 microcontroller, which comes with built-in WiFi and BlueTooth.

**Current version: v0.5rev1**<br>

Get a pre-launch version at our [store](https://www.maplerain.com/en/products).

Facebook [page](https://www.facebook.com/mrrespx/) <br>
Facebook [group](https://www.facebook.com/groups/mrr.espx.users/) (for discussions, etc.)

Features:
- Able to use up to 5 stepper drivers: X, Y, Z, E0, and E1.
- 12V to 24V input power supply.
- Separate power supply for the heat bed.
- X, Y, and Z min endstops.
- Allows the use of a Z-axis probe, such as an inductive sensor, running on the input supply voltage (12V to 24V).
- Physical size of 102mm by 102mm. Mounting holes are 3.5mm in diameter, with centers 4mm from the edges.
- "RESET" button can be used to reset the board.
- Use of jumper pins for TMC stepper driver connections.
- Firmware controlled fans: case, E0, and EXT. These fans can be controlled by firmware, or they can be in the "always on" mode by shorting the respective jumpers.
- EXP3 connector for Creality LCD controller. 
- AUX1 connector for use with an external host, such as the closed-source MKS TFT32 (**Untested!!**).
- **Note: v0.5 has an issue with AUX1 connector where the RX and TX pins are swapped. To use with controllers like MKS TFT32, dupont connectors will be needed to connect each pin to their corresponding pin separately instead of an IDC cable. The `adapters` directory contains a simple AUX1 adapter board that fixes this issue.**

# Firmware

Marlin 2.0 has added support for ESP32, including the use of I2S to drive motor steppers. This board was based on the pins definition file pins_ESP32.h with some modifications based on MRR ESPA. <br>
In addition, [Luc](https://github.com/luc-github) has been working on a Marlin fork which incorporates part of his ESP3D webUI into Marlin itself.<br>

**Note: Due to timer issues with the I2S stream, babystepping will trigger board reset.**<br>
Note: Marlin's linear advance feature does not work with the I2S stepper stream.<br>

## Flashing firmware

- You should be able to flash firmware through the USB port. Depending on your operating system, you may need to install drivers for the CH340. Please use Google or another search engine to find the right CH340 driver for your operating system.
- To flash firmware by directly connecting to TX/RX pins, you will need to connect IO0 to GND, then reboot (press "BOOT" button) to enter flash mode. After flashing the firmware, disconnect IO0 from GND, and press "BOOT" button again to reboot into normal mode.
- Use a baud rate of 115200.

# Jumpers

- 5V_SEL: Connect to VIN for normal operation; only short (close) this jumper to VUSB if you need to power the board via USB. Note: Powering the board with both PSU and USB may cause unstable operation during heating.
- PWR_SEL: Connect the middle pin PWR_SEL to pin labeled "12V" if using 12V; connect PWR_SEL to pin labeled "24V" if using 24V.
- CASE_ON: Leave open for firmware-controlled case fan; short (close) this jumper for case fan to be always on.
- E0_ON: Leave open for firmware-controlled E0 hotend fan; short (close) this jumper for E0 hotend fan to be always on.
- EXT_ON: Leave open for firmware-controlled extra fan (if used); short (close) this jumper for extra fan to be always on.
- Stepper driver jumpers:
  - MS1: VIO to set high; SPI if using TMC SPI mode
  - MS2: VIO to set high; SPI if using TMC SPI mode
  - MS3: VIO to set high; SPI if using TMC SPI mode
  - RST: SLP if using A4988/DRV8825; SPI if using TMC SPI mode
  - Note: Due to a lack of input pins on the ESP32, UART mode is not supported.

# Pins

See separate PIN_DEF.txt file.
Note: I2S pin 151 labeled as `152` on v0.5 board.

# License
Released under CERN Open Hardware Licence v1.2. See LICENSE.txt for details.

## Warning

- This product uses high currents which may cause fires. Use with caution.
- Do not use input voltages higher than 24V. Input current must not exceed 15A.
- Do not attempt to use more than 15A for the heated bed. While the MOSFET is capable of such currents, the connectors are not. If you need more than 15A, use an external MOSFET. In any case, it is highly recommended to use an external MOSFET for the heated bed to avoid drawing high currents through this product.
- If using a current of more than 10A for the heated bed, it is highly recommended to provide active cooling for the board as the MOSFET and adjacent areas can get very hot due to the high current.
- The underside of the board has PCB traces which are exposed for better cooling. These traces may be carrying high currents and can get very hot. DO NOT touch them, and DO NOT allow these traces to come into contact with metal or other conductive materials.
- Do not attempt to use more than 5A for the hot end. While the MOSFET is capable of such currents, the connectors are not. If you need more than 5A, use an external MOSFET.
- The fan outputs can safely drive up to 0.25A, which is more than enough for most cooling fans. Active cooling of the MOSFETs is recommended for driving currents up to 1A; without active cooling, the MOSFETs can get unduly hot when driving more than 0.25A.
- Do not reverse polarity.
- The breakout and endstop pins are rated for 3.3V, which is the voltage the ESP32 operates at. Attempting to feed inputs above 3.3V to these pins may damage the board.
- It is recommended to power the board only via USB (i.e. turn off PSU power supply) when flashing the board.
- This is still a work in progress. It is recommended not to attempt production using this schematic, although it has been extensively tested.

## Disclaimer

This product is provided as-is. While care has been taken to design a safe product, it is the user's responsibility to make sure precautions are taken to prevent damage or injury when using this product. This includes adhering to all warnings provided. By using this product, the user accepts responsibility to bear all liabilities from any damage or injury arising from the use of this product.

## KiCad design adapters/LCD_adapter/LCD_adapter.kicad_pcb

File adapters/LCD_adapter/README.md:

# EXP3 to EXP1/2 adapter
## Adapter to allow use of RepRap full graphics smart controller

This adapter allows the MRR ESPE to use generic LCD12864 controllers (officially the RepRap full graphics smart controller).

To do so, connect EXP3_BRD to the LCD connector on the MRR ESPE. Then, connect EXP1 and EXP2 on the adapter to EXP1 and EXP2 on the controller. (Optional: Connect D5, D6, D7 to unused native ESP32 pins on the MRR ESPE, like IO2, IO4, and IO15. Then define `LCD_PINS_D5`, `LCD_PINS_D6`, and `LCD_PINS_D7` in `pins_MRR_ESPE.h`. The KILL pin is also optional.)

If you want to use the SD card on the controller:
1. Remove SD_EN jumper on the MRR ESPE board.
2. Use jumper wires to connect SCK, MISO, and MOSI from the adapter to the respective pins on the board.
3. Connect SS on the adapter to IO5 on the board.
4. Optional: Connect DET to an unused pin on the board. You will need to edit `pins_MRR_ESPE.h` to define the `SD_DETECT_PIN`.

Parts:
J2: EXP1; IDC-Header_2x05_P2.54mm_Vertical
J3: EXP2; IDC-Header_2x05_P2.54mm_Vertical
J5: EXP3_BRD; IDC-Header_2x05_P2.54mm_Vertical
J6: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical

Connections:
+5V: J2.10, J5.10
BEEPER: J2.1, J5.1
BTN_EN1: J3.5, J5.3
BTN_EN2: J3.3, J5.5
BTN_ENC: J2.2, J5.2
EN: J3.8, J5.4
GND: J2.9, J3.9, J5.9
KILL: J3.10, J6.4
LCD_D4: J2.5, J5.6
LCD_D5: J2.6, J6.6
LCD_D6: J2.7, J6.8
LCD_D7: J2.8, J6.10
LCD_EN: J2.3, J5.8
LCD_RS: J2.4, J5.7
MISO: J3.1, J6.3
MOSI: J3.6, J6.1
SCK: J3.2, J6.5
SD_DET: J3.7, J6.9
SS: J3.4, J6.7

Board: 2 copper layers, 28.0 x 49.0 mm, 4 parts (0 on the bottom side), 19 nets.

## KiCad design current/MRR_ESPE.kicad_pcb

Parts:
C1, C2, C3, C20, C21, C23, C24, C25, C28: 100nF25V; C_0805_2012Metric; Mfg part no. 0805B104K250; LCSC Part Number C128353
C4: 100uF50V; CP_Elec_8x10; Mfg part no. VEJ101M1HTR-0810; LCSC Part Number C176665
C5, C6, C22, C26: 22uF6.3V; C_0805_2012Metric; Mfg part no. CL21A226MQQNNNE; LCSC Part Number C5674
C7: 4.7uF50V; C_1206_3216Metric; Mfg part no. CL31B475KBHNFNE; LCSC Part Number C307575
C8: 820pF50V; C_0805_2012Metric; Mfg part no. 0805B821K500CT; LCSC Part Number C152862
C9: 56pF50V; C_0805_2012Metric; Mfg part no. 0805N560J500CT; LCSC Part Number C296102
C10: 100nF50V; C_0805_2012Metric; Mfg part no. GCM21BR71H104KA37L; LCSC Part Number C161260
C11: 1nF16V; C_0805_2012Metric; Mfg part no. 0805B103K500NT; LCSC Part Number C52278
C12: 47uF10V; C_1206_3216Metric; Mfg part no. LMK316BJ476ML-T; LCSC Part Number C92821
C13, C14: 47uF6.3V; C_0805_2012Metric; Mfg part no. JMK212BJ476MG-T; LCSC Part Number C87159
C15, C16, C17, C18, C27: 100uF35V; CP_Elec_6.3x7.7; Mfg part no. CS1V101M-CRE77; LCSC Part Number C97811
C19: 100uF6.3V; C_1206_3216Metric; Mfg part no. CL31A107MQHNNNE; LCSC Part Number C15008
D1: LED_BED; LED_0805; Mfg part no. 17-21SURC/S530-A3/TR8; LCSC Part Number C72037
D2: 1N4148W; D_SOD-123; Mfg part no. 1N4148W; LCSC Part Number C81598
D3: LED_E0; LED_0805; Mfg part no. 17-21SURC/S530-A3/TR8; LCSC Part Number C72037
D4, D5: 1N4007W; D_SOD-123F; Mfg part no. 1N4007W; LCSC Part Number C108803
D7, D8: PESD5V0S1BA; D_SOD-323; Mfg part no. PESD5V0S1BA,115; LCSC Part Number C19224
D9: B540C-13-F; D_SMC; Mfg part no. B540C-13-F; LCSC Part Number C72264
D10: LED_3V; LED_0805; Mfg part no. 17-21SYGC/S530-E2/TR8; LCSC Part Number C73548
D11: LED_5V; LED_0805; Mfg part no. 17-21SYGC/S530-E2/TR8; LCSC Part Number C73548
D12: LED_VIN; LED_0805; Mfg part no. 17-21/BHC-XL2M2TY/3T; LCSC Part Number C72035
D13: LED_VBED; LED_0805; Mfg part no. 17-21/BHC-XL2M2TY/3T; LCSC Part Number C72035
D14, D15: 1N5819W; D_SOD-123; Mfg part no. 1N5819W; LCSC Part Number C169540
F1: 15A 2410; Littelfuse_0451; Mfg part no. 0451015.MRL; LCSC Part Number C44480
F2: 30A 3912; Littelfuse_0456; Mfg part no. 0456030.ER; LCSC Part Number C187558
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
J1: X_MIN; JST_XH_B03B-XH-A_1x03_P2.50mm_Vertical; Mfg part no. B3B-XH-A(LF)(SN); LCSC Part Number C144394
J2: Z_MIN; JST_XH_B03B-XH-A_1x03_P2.50mm_Vertical; Mfg part no. B3B-XH-A(LF)(SN); LCSC Part Number C144394
J3: BED; TerminalBlock_Phoenix_MKDS-3-2-5.08_1x02_P5.08mm_Horizontal; Mfg part no. MKDS3/2-5.08; LCSC Part Number C89120
J4: Micro_SD_Card_China; Conn_uSDcard; Mfg part no. TF-15×15; LCSC Part Number C111196
J5: Y_MIN; JST_XH_B03B-XH-A_1x03_P2.50mm_Vertical; Mfg part no. B3B-XH-A(LF)(SN); LCSC Part Number C144394
J6: Z_PROBE; JST_XH_B03B-XH-A_1x03_P2.50mm_Vertical; Mfg part no. B3B-XH-A(LF)(SN); LCSC Part Number C144394
J7: E0; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; Mfg part no. MKDSN1.5/2-5.08; LCSC Part Number C91153
J8: T_EXT; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
J9: PWR_IN; TerminalBlock_Phoenix_MKDS-3-4-5.08_1x04_P5.08mm_Horizontal; Mfg part no. MKDS3/4-5.08; LCSC Part Number C90087
J10: PART_FAN; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
J11: UNUSED; PinHeader_2x05_P2.54mm_Vertical; Mfg part no. C124387; LCSC Part Number C124387
J12: T_BED; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
J13: T_E0; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
J14: I2C/SPI; PinHeader_2x05_P2.54mm_Vertical; Mfg part no. C124387; LCSC Part Number C124387
J15: AUX1; IDC-Header_2x04_P2.54mm_Vertical; Mfg part no. C9135; LCSC Part Number C9135
J16: USB_B_Micro; USB_Micro-B_Molex-105017-0001; Mfg part no. 105017-0001; LCSC Part Number C136000
J17: HS_FAN; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
J18: CASE_FAN; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
J19: EXT_FAN; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
J20: CS_PINS; PinHeader_1x05_P2.54mm_Vertical; Mfg part no. C124379; LCSC Part Number C124379
J21: X_MOTOR; PinHeader_1x04_P2.54mm_Vertical; Mfg part no. C124378; LCSC Part Number C124378
J22: Z_MOTOR; PinHeader_2x04_P2.54mm_Vertical; Mfg part no. C124386; LCSC Part Number C124386
J23: Y_MOTOR; PinHeader_1x04_P2.54mm_Vertical; Mfg part no. C124378; LCSC Part Number C124378
J24: E0_MOTOR; PinHeader_1x04_P2.54mm_Vertical; Mfg part no. C124378; LCSC Part Number C124378
J25: E1_MOTOR; PinHeader_1x04_P2.54mm_Vertical; Mfg part no. C124378; LCSC Part Number C124378
J26: EXP3; IDC-Header_2x05_P2.54mm_Vertical; Mfg part no. C5665; LCSC Part Number C5665
JP1: X_MS1; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP2: Y_MS1; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP3: Z_MS1; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP4: E0_MS1; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP5: X_MS2; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP6: Y_MS2; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP7: Z_MS2; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP8: E0_MS2; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP9: X_MS3; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP10: Y_MS3; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP11: Z_MS3; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP12: E0_MS3; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP13: X_RST; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP14: Y_RST; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP15: Z_RST; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP16: E0_RST; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP17: BEEP_SEL; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
JP18: BED_SEL; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP19: FAN_SEL; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP20: E0_SEL; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP21: HS_ON; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
JP22: E1_MS1; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP23: CASE_ON; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
JP24: EXT_ON; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
JP25: E1_MS2; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP26: E1_MS3; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP27: E1_RST; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP28: 5V_SEL; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
JP29: SD_EN; PinHeader_1x02_P2.54mm_Vertical; Mfg part no. C124375; LCSC Part Number C124375
JP30: PWR_SEL; PinHeader_1x03_P2.54mm_Vertical; Mfg part no. C124376; LCSC Part Number C124376
L1: 4.7uH4.5A; SMMS0530; Mfg part no. SMMS0530-4R7M; LCSC Part Number C181722
Q1: IRLS3034PBF; TO-263-2
Q2: IRLR8743TRPBF; TO-252-2
Q3, Q6: WST3392; SOT-23-6_Handsoldering; Mfg part no. WST3392; LCSC Part Number C148366
Q4, Q5: S9014; SOT-23; Mfg part no. S9014; LCSC Part Number C181164
R1, R3, R4, R8, R32, R33, R37, R39, R41: 10K; R_0805_2012Metric; Mfg part no. 0805W8F1002T5E; LCSC Part Number C38522
R2, R16, R17, R19, R20: 4.7K; R_0805_2012Metric; Mfg part no. 0805W8F4701T5E; LCSC Part Number C17673
R5, R9, R30, R31: 2.2K; R_0805_2012Metric; Mfg part no. 0805W8F2201T5E; LCSC Part Number C17520
R6, R10, R12, R13, R40: 10R; R_0805_2012Metric; Mfg part no. 0805W8F100JT5E; LCSC Part Number C17415
R7, R11, R14, R34, R42: 100K; R_0805_2012Metric; Mfg part no. 0805W8F1003T5E; LCSC Part Number C149504
R15, R22, R23: 12K; R_0805_2012Metric; Mfg part no. 0805W8F1202T5E; LCSC Part Number C17444
R18: 73.2K; R_0805_2012Metric; Mfg part no. WR08X7322FTL; LCSC Part Number C170958
R21: 23.7K; R_0805_2012Metric; Mfg part no. WR08X2372FTL; LCSC Part Number C170848
R24: 60.4K; R_0805_2012Metric; Mfg part no. RC0805FR-0760K4L; LCSC Part Number C273994
R25: 11.5K; R_0805_2012Metric; Mfg part no. 0805W8F1152T5E; LCSC Part Number C17418
R26, R27: 0R; R_0805_2012Metric; Mfg part no. 0805W8F0000T5E; LCSC Part Number C17477
R28: 220R; R_0805_2012Metric; Mfg part no. 0805W8F2200T5E; LCSC Part Number C17557
R29, R36: 330R; R_0805_2012Metric; Mfg part no. 0805W8F3300T5E; LCSC Part Number C17630
R35, R38: 1K; R_0805_2012Metric; Mfg part no. 0805W8F1001T5E; LCSC Part Number C17513
SW1: RESET; 6x6mmTactileSwitch; Mfg part no. K2-6639SP-C4SC-04; LCSC Part Number C83206
U1: ESP32-WROOM-32D; ESP32-WROOM-32; Mfg part no. ESP32-WROOM-32; LCSC Part Number C95209
U2: TPS54340DDA; TI_SO-PowerPAD-8_ThermalVias; Mfg part no. TPS54340DDAR; LCSC Part Number C45886
U3: CH340C; SOIC-16_3.9x9.9mm_P1.27mm; Mfg part no. CH340C; LCSC Part Number C84681
U4: AMS1117-3.3; SOT-223-3_TabPin2; Mfg part no. AMS1117-3.3; LCSC Part Number C6186
U5, U6, U8, U9, U11: Pololu_board; Pololu_Breakout-16_15.2x20.3mm; Mfg part no. x2; LCSC Part Number C27438
U7, U13, U14, U15: 74HCT595; TSSOP-16_4.4x5mm_P0.65mm; Mfg part no. MC74HCT595ADTR2G; LCSC Part Number C152276
U10: TLP182; MFSOP6-4_4.4x3.6mm_P1.27mm; Mfg part no. TLP182(GB-TPL,E; LCSC Part Number C96457

Connections:
5V1: C12.2, D14.2 (A), L1.2, R24.1
+3V3: C11.2, C14.1, C19.1, C22.1, C23.1, J1.1, J2.1, J4.4 (VDD), J5.1, J14.2, JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), JP7.3 (B), JP8.3 (B), JP9.3 (B), JP10.3 (B), JP11.3 (B), JP12.3 (B), JP22.3 (B), JP25.3 (B), JP26.3 (B), R1.1, R2.1, R3.2, R4.2, R8.2, R15.1, R16.1, R17.1, R19.2, R20.2, R28.2, R32.1, R33.1, R37.1, R39.1, R41.1, U1.2 (VDD), U3.4 (V3), U3.16 (VCC), U4.2 (VO), U5.10 (+5V), U6.10 (+5V), U7.10 (~SRCLR), U8.10 (+5V), U9.10 (+5V), U11.10 (+5V), U13.10 (~SRCLR), U14.10 (~SRCLR), U15.10 (~SRCLR)
+5V: C13.1, C20.2, C21.2, C24.2, C25.2, J15.1, J15.2, J26.10, JP28.2 (C), R29.2, U4.3 (VI), U7.16 (VCC), U13.16 (VCC), U14.16 (VCC), U15.16 (VCC)
/D+: D8.1 (A1), J16.3 (D+), U3.5 (UD+)
/D-: D7.1 (A1), J16.2 (D-), U3.6 (UD-)
BED_EXT_IN: JP18.2 (C), R36.1
BEEPER_PIN: J26.1, JP17.1
BTN_EN1: J14.7, J26.3, Q5.3 (C), R1.2, U1.25 (IO0)
BTN_EN2: J26.5, U1.14 (IO12)
BTN_ENC: J26.2, U1.13 (IO14)
COMP: C9.1, R21.1, U2.6 (COMP)
DTR: Q5.2 (E), R22.2, U3.13 (~DTR)
E0_CS: J20.4, JP12.1 (A)
E0_MS1: JP4.2 (C), U9.2 (MS1)
E0_MS2: JP8.2 (C), U9.3 (MS2)
E0_MS3: JP12.2 (C), U9.4 (MS3)
E0_RST: JP16.2 (C), U9.5 (~RST)
E0_SLP: JP16.3 (B), U9.6 (~SLEEP)
E1_CS: J20.5, JP26.1 (A)
E1_MS1: JP22.2 (C), U11.2 (MS1)
E1_MS2: JP25.2 (C), U11.3 (MS2)
E1_MS3: JP26.2 (C), U11.4 (MS3)
E1_RST: JP27.2 (C), U11.5 (~RST)
E1_SLP: JP27.3 (B), U11.6 (~SLEEP)
EN: C28.1, J26.4, Q4.3 (C), R15.2, SW1.2, U1.3 (EN)
FB: R24.2, R25.1, U2.5 (FB)
GND: C1.1, C2.1, C3.1, C4.2, C5.1, C6.1, C7.1, C8.2, C9.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.1, C22.2, C23.2, C24.1, C25.1, C26.1, C27.2, C28.2, D5.2 (A), D7.2 (A2), D8.2 (A2), D9.2 (A), D10.1 (K), D11.1 (K), D12.1 (K), J1.2, J2.2, J4.6 (VSS), J5.2, J6.2, J8.2, J9.2, J12.2, J13.2, J14.4, J15.3, J15.4, J16.5 (GND), J16.6 (Shield), J26.9, JP21.2, JP23.2, JP24.2, Q2.3 (S), Q3.2, Q3.5, Q6.2, Q6.5, R7.1, R11.1, R14.1, R18.1, R25.2, R34.1, R42.1, SW1.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39, U2.7 (GND), U2.9 (GNDPAD), U3.1 (GND), U4.1 (GND), U5.9 (GND), U5.15 (GND), U6.9 (GND), U6.15 (GND), U7.8 (GND), U7.13 (~OE), U8.9 (GND)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
GNDD: D4.2 (A), D13.1 (K), J9.3, Q1.3 (S), R35.1
HEATER_BED: JP18.1 (A), U1.26 (IO4)
HEATER_E0: JP20.1 (A), U1.24 (IO2)
I2S_BCK: U1.10 (IO25), U7.11 (SRCLK), U13.11 (SRCLK), U14.11 (SRCLK), U15.11 (SRCLK)
I2S_DATA: U1.12 (IO27), U7.14 (SER)
I2S_WS: U1.11 (IO26), U7.12 (RCLK), U13.12 (RCLK), U14.12 (RCLK), U15.12 (RCLK)
IO5: J14.9, JP29.1, U1.29 (IO5)
IO34: C26.2, J8.1, R2.2, U1.6 (IO34)
LCD_PINS_D4: J26.6, U1.27 (IO16)
LCD_PINS_EN: J26.8, U1.28 (IO17)
LCD_PINS_RS: J26.7, U1.16 (IO13)
MISO: J4.7 (DAT0), J14.3, JP13.1 (A), JP14.1 (A), JP15.1 (A), JP16.1 (A), JP27.1 (A), U1.31 (IO19)
MOSI: J4.3 (CMD), J14.1, JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A), JP22.1 (A), U1.37 (IO23)
unnamed: C8.1, R21.2
unnamed: C10.1, D9.1 (K), L1.1, U2.8 (SW)
unnamed: C10.2, U2.1 (BOOT)
unnamed: D1.1 (K), J3.2, Q1.2 (D)
unnamed: D1.2 (A), R5.1
unnamed: D2.1 (K), J6.3
unnamed: D3.1 (K), J7.2, Q2.2 (D)
unnamed: D3.2 (A), R9.1
unnamed: D10.2 (A), R28.1
unnamed: D11.2 (A), R29.1
unnamed: D12.2 (A), R30.1
unnamed: D13.2 (A), R31.1
unnamed: D14.1 (K), JP28.3 (B)
unnamed: D15.1 (K), JP28.1 (A)
unnamed: F1.2, J9.1
unnamed: F2.2, J9.4
unnamed: J10.2, Q3.6
unnamed: J17.2, JP21.1, Q3.4
unnamed: J18.2, JP23.1, Q6.6
unnamed: J19.2, JP24.1, Q6.4
unnamed: J21.1, U5.14 (2B)
unnamed: J21.2, U5.13 (2A)
unnamed: J21.3, U5.12 (1B)
unnamed: J21.4, U5.11 (1A)
unnamed: J23.1, U8.14 (2B)
unnamed: J23.2, U8.13 (2A)
unnamed: J23.3, U8.12 (1B)
unnamed: J23.4, U8.11 (1A)
unnamed: J24.1, U9.14 (2B)
unnamed: J24.2, U9.13 (2A)
unnamed: J24.3, U9.12 (1B)
unnamed: J24.4, U9.11 (1A)
unnamed: J25.1, U11.14 (2B)
unnamed: J25.2, U11.13 (2A)
unnamed: J25.3, U11.12 (1B)
unnamed: J25.4, U11.11 (1A)
unnamed: JP30.1 (A), R35.2, R38.1
unnamed: JP30.3 (B), R38.2, U10.4
unnamed: Q2.1 (G), R10.1
unnamed: Q3.1, R13.1
unnamed: Q3.3, R6.1
unnamed: Q4.1 (B), R22.1
unnamed: Q5.1 (B), R23.1
unnamed: Q6.1, R12.1
unnamed: Q6.3, R40.1
unnamed: R18.2, U2.4 (RT/CLK)
unnamed: R26.2, U3.2 (TXD)
unnamed: R27.2, U3.3 (RXD)
unnamed: R36.2, U10.1
unnamed: U13.9 (QH'), U14.14 (SER)
unnamed: U7.9 (QH'), U13.14 (SER)
unnamed: U14.9 (QH'), U15.14 (SER)
PART_FAN: JP19.1 (A), U1.23 (IO15)
Q128: R32.2, U5.1 (EN), U7.15 (QA)
Q129: U5.7 (STEP), U7.1 (QB)
Q130: U5.8 (DIR), U7.2 (QC)
Q131: R33.2, U7.3 (QD), U8.1 (EN)
Q132: U7.4 (QE), U8.7 (STEP)
Q133: U7.5 (QF), U8.8 (DIR)
Q134: R37.2, U6.1 (EN), U7.6 (QG)
Q135: U6.7 (STEP), U7.7 (QH)
Q136: U6.8 (DIR), U13.15 (QA)
Q137: R39.2, U9.1 (EN), U13.1 (QB)
Q138: U9.7 (STEP), U13.2 (QC)
Q139: U9.8 (DIR), U13.3 (QD)
Q140: R41.2, U11.1 (EN), U13.4 (QE)
Q141: U11.7 (STEP), U13.5 (QF)
Q142: U11.8 (DIR), U13.6 (QG)
Q143: J11.1, U13.7 (QH)
Q144: JP18.3 (B), U14.15 (QA)
Q145: JP20.3 (B), U14.1 (QB)
Q146: JP19.3 (B), U14.2 (QC)
Q147: R12.2, R34.2, U14.3 (QD)
Q148: R6.2, R7.2, U14.4 (QE)
Q149: R40.2, R42.2, U14.5 (QF)
Q150: J11.2, U14.6 (QG)
Q151: JP17.2, U14.7 (QH)
Q152: J11.3, U15.15 (QA)
Q153: J11.4, U15.1 (QB)
Q154: J11.5, U15.2 (QC)
Q155: J11.6, U15.3 (QD)
Q156: J11.7, U15.4 (QE)
Q157: J11.8, U15.5 (QF)
Q158: J11.9, U15.6 (QG)
Q159: J11.10, U15.7 (QH)
RTS: Q4.2 (E), R23.2, U3.14 (~RTS)
SCK: J4.5 (CLK), J14.5, JP5.1 (A), JP6.1 (A), JP7.1 (A), JP8.1 (A), JP25.1 (A), U1.30 (IO18)
SCL: J14.6, R20.1, U1.36 (IO22)
SDA: J14.8, R19.1, U1.33 (IO21)
SS: J4.2 (DAT3/CD), JP29.2
TEMP_BED_PIN: C5.2, J12.1, R16.2, U1.5 (SENSOR_VN)
TEMP_E0_PIN: C6.2, J13.1, R17.2, U1.4 (SENSOR_VP)
TO_FAN_E0: JP19.2 (C), R13.2, R14.2
TO_HEATER_BED: JP30.2 (C), Q1.1 (G)
TO_HEATER_E0: JP20.2 (C), R10.2, R11.2
UART+: J15.8, R27.1, U1.35 (TXD0/IO1)
UART-: J15.6, R26.1, U1.34 (RXD0/IO3)
VBED: D4.1 (K), F2.1, J3.1, R5.2, R31.2, U10.6
VIN: C4.1, C7.2, C15.1, C16.1, C17.1, C18.1, C27.1, D5.1 (K), F1.1, J6.1, J7.1, J10.1, J17.1, J18.1, J19.1, R9.2, R30.2, U2.2 (VIN), U5.16 (+12V), U6.16 (+12V), U8.16 (+12V), U9.16 (+12V), U11.16 (+12V)
VUSB: D15.2 (A), J16.1 (VBUS)
X_CS: J20.1, JP9.1 (A)
X_MIN: C1.2, J1.3, R3.1, U1.7 (IO35)
X_MS1: JP1.2 (C), U5.2 (MS1)
X_MS2: JP5.2 (C), U5.3 (MS2)
X_MS3: JP9.2 (C), U5.4 (MS3)
X_RST: JP13.2 (C), U5.5 (~RST)
X_SLP: JP13.3 (B), U5.6 (~SLEEP)
Y_CS: J20.2, JP10.1 (A)
Y_MIN: C3.2, J5.3, R8.1, U1.8 (IO32)
Y_MS1: JP2.2 (C), U8.2 (MS1)
Y_MS2: JP6.2 (C), U8.3 (MS2)
Y_MS3: JP10.2 (C), U8.4 (MS3)
Y_RST: JP14.2 (C), U8.5 (~RST)
Y_SLP: JP14.3 (B), U8.6 (~SLEEP)
Z_1A: J22.7, J22.8, U6.11 (1A)
Z_1B: J22.5, J22.6, U6.12 (1B)
Z_2A: J22.3, J22.4, U6.13 (2A)
Z_2B: J22.1, J22.2, U6.14 (2B)
Z_CS: J20.3, JP11.1 (A)
Z_MIN: C2.2, D2.2 (A), J2.3, R4.1, U1.9 (IO33)
Z_MS1: JP3.2 (C), U6.2 (MS1)
Z_MS2: JP7.2 (C), U6.3 (MS2)
Z_MS3: JP11.2 (C), U6.4 (MS3)
Z_RST: JP15.2 (C), U6.5 (~RST)
Z_SLP: JP15.3 (B), U6.6 (~SLEEP)

Notes on the sheet:
Microcontroller
MicroSD card
Power
Step-down: 5V
Step-down: 3.3V
Power indicator LEDs
Power input
USB to serial
5V input protection
Heater: Bed
Heater: E0
Part-cooling fan
Stepper drivers
Thermistors
Endstops
Reset switch
Connectors
Stepper driver jumpers
CS Pins for SPI mode
Licensed under CERN OHL v1.2
Case fan
Heat sink fan
Extra fan
Selection jumpers
